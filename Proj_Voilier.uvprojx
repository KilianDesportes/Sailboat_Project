# Keil uVision project Proj_Voilier.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Proj_Voilier
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group LL
    ./ProjKEIL_Chrono_TIM_IT_LL/LLDrivers/src/: stm32f1xx_ll_adc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c
  group src
    ./: girouette.c voile.c accel.c RxFM.c TxFM.c plate.c carteElec.c
  group header
    ./: girouette.h voile.h accel.h RxFM.h TxFM.h carteElec.h plate.h
